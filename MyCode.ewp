# IAR project MyCode.ewp, settings and files
configuration Debug (SAM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSAM8xRCRI Unspecified SAM8xRCRI
  ICCSAM8.CCIncludePath2: F:\GitHub\SAM8-Code\Head
  ICCSAM8.CCStdIncludePath: $TOOLKIT_DIR$\inc\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnksam8.xcl
  XLINK.XlinkStackSize: 1
configuration Release (SAM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: S3F94C8 S3F94C8
  ICCSAM8.CCDefines: NDEBUG
  ICCSAM8.CCIncludePath2: F:\GitHub\SAM8-Code-94c8\Head
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnksam8_s3f94c4.xcl
  group (top)
    ./: main.c
  group Head
    Head/: 74HC164.h adc.h config.h main.h PWM.h time.h TM1629.h
  group Resource
    Resource/: 74HC164.c adc.c PWM.c time.c TM1629.c
